# Keil uVision project blink_led.uvprojx, settings and files
target blink_led (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink_led
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\freertos_add\include;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\mylib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c
  group lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group free_rtos
    ./freertos_add/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group mylib
    ./mylib/: mprintf.c mprintf.h OLED.c OLED.h i2c.c i2c.h adc.c adc.h server.c sever.h keybad.c keybad.h spi.c spi.h rc522.c rc522.h store.c store.h led.c led.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
